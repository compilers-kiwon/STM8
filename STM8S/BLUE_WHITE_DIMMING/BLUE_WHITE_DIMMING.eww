<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BLUE_WHITE_DIMMING.ewp</path>
    </project>
    <batchBuild />
</workspace>
